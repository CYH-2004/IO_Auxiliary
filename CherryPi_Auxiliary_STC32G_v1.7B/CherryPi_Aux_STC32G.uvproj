# Keil uVision project CherryPi_Aux_STC32G.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: CherryPi_Aux_STC32G +hex
  group Core
    ./Core/: main.c
  group Basic
    ./Basic/: Timer.c IIC_Slave.c PWMA.c Uart1.c
  group CherryPi_Aux
    ./CherryPi_Aux/: CherryPi_aux.c
